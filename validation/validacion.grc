options:
  parameters:
    author: Juan Jose GARRIDO
    generate_options: qt_gui
    id: leo_channel
    output_language: python
    run_options: run
    title: Simulador de canal
  states: {}

blocks:
- name: pointing_error
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '1'
  states: {}
- name: retardo_en_milisegundos
  id: variable
  parameters:
    value: '500'
  states: {}
- name: retardo_en_muestras
  id: variable
  parameters:
    value: (samp_rate*(retardo_en_milisegundos/1000))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: satellite_rx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '55'
    beamwidth: '360'
    boom_length: '2.35'
    circumference: '1'
    diameter: '5.4'
    frequency: 435e6
    gain: '6'
    lp: '0.5'
    pointing_error: pointing_error
    polarization: '3'
    rolloff_gain: '0'
    turn_spacing: '0.25'
    turns: '10'
    type: '6'
  states: {}
- name: satellite_tx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '55'
    beamwidth: '50'
    boom_length: '2.35'
    circumference: '1'
    diameter: '5.4'
    frequency: 435e6
    gain: '14'
    lp: '0.5'
    pointing_error: pointing_error
    polarization: '3'
    rolloff_gain: '0'
    turn_spacing: '0.25'
    turns: '10'
    type: '6'
  states: {}
- name: tracker_rx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '0'
    beamwidth: '0'
    boom_length: '0'
    circumference: '0'
    diameter: '0'
    frequency: 435e6
    gain: '0'
    lp: '0.5'
    pointing_error: '0'
    polarization: '2'
    rolloff_gain: '0'
    turn_spacing: '0'
    turns: '0'
    type: '6'
  states: {}
- name: tracker_tx_antenna
  id: variable_antenna
  parameters:
    aperture_efficiency: '55'
    beamwidth: '50'
    boom_length: '2.35'
    circumference: '1'
    diameter: '5.4'
    frequency: 145.8e6
    gain: '14'
    lp: '0.5'
    pointing_error: pointing_error
    polarization: '0'
    rolloff_gain: '0'
    turn_spacing: '0.25'
    turns: '10'
    type: '5'
  states: {}
- name: variable_leo_model_def_0
  id: variable_leo_model_def
  parameters:
    atmo_gases_attenuation: '2'
    doppler_shift_enum: '7'
    enable_link_margin: 'True'
    fspl_attenuation_enum: '5'
    mode: '1'
    pointing_attenuation_enum: '0'
    precipitation_attenuation: '4'
    rainfall_rate: '90'
    surface_watervap_density: '7.5'
    temperature: '20'
    tracker: variable_tracker_0
    value: '''fine'''
  states: {}
- name: variable_satellite_0
  id: variable_satellite
  parameters:
    comm_freq_rx: 435e6
    comm_freq_tx: 435e6
    noise_figure: '12'
    noise_temp: '190'
    rx_antenna: satellite_rx_antenna
    rx_bw: '1200'
    tle_1: 1 25544U 98067A   18268.52547184  .00016717  00000-0  10270-3 0  9019
    tle_2: 2 25544  51.6373 238.6885 0003885 206.9748 153.1203 15.53729445 14114
    tle_title: ISS
    tx_antenna: satellite_tx_antenna
    tx_power_dbm: '27'
    value: '''ok'''
  states: {}
- name: variable_tracker_0
  id: variable_tracker
  parameters:
    comm_freq_rx: 435e6
    comm_freq_tx: 435E6
    gs_alt: '1'
    gs_lat: '35.3333'
    gs_lon: '25.1833'
    noise_figure: '1'
    noise_temp: '210'
    obs_end: '2018-09-25T15:58:35.0000000Z'
    obs_start: '2018-09-25T15:48:25.0000000Z'
    rx_antenna: tracker_rx_antenna
    rx_bw: '19200'
    satellite_info: variable_satellite_0
    time_resolution_us: '10000'
    tx_antenna: tracker_tx_antenna
    tx_power_dbm: '37'
    value: '''fine'''
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: leo_channel_model_0
  id: leo_channel_model
  parameters:
    model: model_variable
    noise_type: '1'
    sample_rate: samp_rate
    value: '''fine'''
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 1003e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 1003e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_delay_0_0, '0']
- [blocks_delay_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_delay_0_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_magphase_to_complex_0, '0', osmosdr_sink_0, '0']
- [leo_channel_model_0, '0', blocks_complex_to_magphase_0, '0']
- [osmosdr_source_0, '0', leo_channel_model_0, '0']

metadata:
  file_format: 1
